# Keil uVision project baseflightplus.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bfp +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: accelCalibration.c computeAxisCommands.c config.c flightCommand.c gyroTempCalibration.c lowPassFilter.c MadgwickAHRS.c magCalibration.c main.c mixer.c pid.c serial.c utilities.c board.h ahrsCalibration.c chr6dmAHRS.c chr6dmMatrix3x3.c MargAHRS.c
  group System
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
    ./src/startup/: startup_stm32f10x_md.s
  group Drivers
    ./src/: adxl345.c bmp085.c drv_i2c.c drv_pwmInput.c drv_pwmOutput.c drv_system.c drv_uart.c hmc5883.c mpu3050.c
